## config/boards/4pplet/whkb_pro2/Kconfig.whkb_pro2
```kconfig
# Copyright (c) 2023 Kan-Ru Chen
# SPDX-License-Identifier: Apache-2.0

config BOARD_WHKB_PRO2
	select SOC_NRF52840_QIAA
```
